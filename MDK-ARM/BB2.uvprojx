# Keil uVision project BB2.uvprojx, settings and files
target BB2 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: BB2 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx ARM_MATH_CM4
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/LwIP/src/apps/httpd;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include;../ModbusMaster;../ModbusSlave;../FTP;..\Src;..\Middlewares\ST;..\Middlewares\ST\STM32_USB_Host_Library\Core;..\Middlewares\ST\STM32_USB_Host_Library\Class;..\Middlewares\ST\STM32_USB_Host_Library\Class\CDC\Inc;..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0xf4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c queue.c tasks.c timers.c list.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application/User
    ../Src/: fatfs.c stm32f4xx_hal_msp.c main.c freertos.c lwip.c stm32f4xx_it.c ethernetif.c bsp_driver_sd.c httpserver-netconn.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c netifapi.c netdb.c api_msg.c sockets.c netbuf.c tcpip.c err.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c ip6.c inet6.c nd6.c icmp6.c mld6.c ip6_frag.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/core/: memp.c raw.c tcp_out.c stats.c tcp.c ip.c sys.c mem.c init.c netif.c dns.c tcp_in.c def.c udp.c pbuf.c inet_chksum.c timeouts.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: lcp.c utils.c ppp.c pppol2tp.c vj.c eap.c ccp.c demand.c mppe.c ipv6cp.c pppoe.c ipcp.c upap.c auth.c pppos.c multilink.c pppapi.c fsm.c chap-md5.c ecp.c magic.c chap-new.c pppcrypt.c chap_ms.c eui64.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c icmp.c ip4.c dhcp.c autoip.c ip4_addr.c ip4_frag.c etharp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c slipif.c ethernet.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: sha1.c md5.c arc4.c md4.c des.c
    ../Middlewares/Third_Party/LwIP/src/apps/httpd/: fs.c httpd.c
  group Modbus Master
    ../ModbusMaster/: mbcrc.c ModBus_master.c
  group Modbus Slave
    ../ModbusSlave/: Modbus_slave.c
  group FTP
    ../FTP/: ftp.c
  group LogSD
    ../Src/: LogSD.c Event.c
  group USB
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Src/: usb_host.c usbh_conf.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
software components: CMSIS:CORE 4.1.0
